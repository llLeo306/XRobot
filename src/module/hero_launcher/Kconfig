## src/module/hero_launcher/Kconfig
```kconfig
config MODULE_HERO_LAUNCHER_TASK_STACK_DEPTH
    int "HERO_LAUNCHER任务堆栈大小"
    range 128 4096
    default 512
```
